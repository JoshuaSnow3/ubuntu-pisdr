options:
  parameters:
    generate_options: qt_gui
    id: pisdr
    output_language: python
    title: SDR
  states: {}

blocks:
- name: freq
  id: variable
  parameters:
    value: 105.5e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2048000'
  states: {}
- name: source_chooser
  id: variable_qtgui_chooser
  parameters:
    label: Source
    label0: FM
    label1: CW
    num_opts: '2'
    option0: '0'
    option1: '1'
    type: int
    value: '0'
    widget: radio_buttons
  states: {}
- name: squelch
  id: variable
  parameters:
    value: '-20'
  states: {}
- name: variable_qtgui_label_0
  id: variable_qtgui_label
  parameters:
    formatter: 'lambda x: f''{x:5f}'''
    gui_hint: 0,1,1,1
    label: 'Frequency (MHz): '
    type: real
    value: variable_qtgui_range_0 / 1e6
  states: {}
- name: variable_qtgui_range_0
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0,1,1
    label: Frequency
    start: 30e6
    step: '10000'
    stop: 300e6
    value: freq
    widget: slider
  states: {}
- name: variable_qtgui_range_1
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,2,1,1
    label: Squelch
    rangeType: int
    start: '-100'
    step: '1'
    stop: '0'
    value: squelch
  states: {}
- name: analog_pwr_squelch_xx_0
  id: analog_pwr_squelch_xx
  parameters:
    alpha: '1'
    gate: 'True'
    ramp: '0'
    threshold: variable_qtgui_range_1
    type: complex
  states: {}
- name: analog_pwr_squelch_xx_0_0
  id: analog_pwr_squelch_xx
  parameters:
    alpha: '1'
    gate: 'True'
    ramp: '0'
    threshold: variable_qtgui_range_1
    type: complex
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '10'
    quad_rate: 500e3
  states: {}
- name: audio_sink_0_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: audio_sink_0_0_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '1'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '1'
    type: float
  states: {}
- name: blocks_selector_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: '0'
    num_inputs: '1'
    num_outputs: '2'
    output_index: source_chooser
    type: complex
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: samp_rate/4
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 100e3
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 100e3
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 50e3
    win: window.WIN_HAMMING
  states: {}
- name: note_0
  id: note
  parameters:
    note: FM
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: variable_qtgui_range_0
    fftsize: '512'
    plotconst: 'False'
    plottime: 'False'
    showports: 'True'
    showrf: 'True'
    type: complex
  states: {}
- name: rational_resampler_xxx_1_0
  id: rational_resampler_xxx
  parameters:
    decim: '4'
    interp: '1'
    type: ccf
  states: {}
- name: rational_resampler_xxx_1_0_0
  id: rational_resampler_xxx
  parameters:
    decim: '50'
    interp: '50'
    type: fff
  states: {}
- name: rational_resampler_xxx_1_0_0_0
  id: rational_resampler_xxx
  parameters:
    decim: '50'
    interp: '50'
    type: fff
  states: {}
- name: rational_resampler_xxx_1_0_1
  id: rational_resampler_xxx
  parameters:
    decim: '4'
    interp: '1'
    type: ccf
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    bb_gain0: '20'
    freq0: variable_qtgui_range_0
    gain0: '40'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [analog_pwr_squelch_xx_0, '0', analog_wfm_rcv_0, '0']
- [analog_pwr_squelch_xx_0_0, '0', blocks_complex_to_float_0, '0']
- [analog_wfm_rcv_0, '0', rational_resampler_xxx_1_0_0, '0']
- [blocks_complex_to_float_0, '0', rational_resampler_xxx_1_0_0_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', audio_sink_0_0, '0']
- [blocks_multiply_const_vxx_0_0_0, '0', audio_sink_0_0_0, '0']
- [blocks_selector_0, '0', rational_resampler_xxx_1_0, '0']
- [blocks_selector_0, '1', rational_resampler_xxx_1_0_1, '0']
- [low_pass_filter_0, '0', analog_pwr_squelch_xx_0, '0']
- [low_pass_filter_0_0, '0', analog_pwr_squelch_xx_0_0, '0']
- [rational_resampler_xxx_1_0, '0', low_pass_filter_0, '0']
- [rational_resampler_xxx_1_0_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [rational_resampler_xxx_1_0_0_0, '0', blocks_multiply_const_vxx_0_0_0, '0']
- [rational_resampler_xxx_1_0_1, '0', low_pass_filter_0_0, '0']
- [rtlsdr_source_0, '0', blocks_selector_0, '0']
- [rtlsdr_source_0, '0', qtgui_sink_x_0, '0']

metadata:
  file_format: 1
