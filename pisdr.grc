options:
  parameters:
    generate_options: qt_gui
    id: pisdr
    output_language: python
    title: SDR
  states: {}

blocks:
- name: filter_test
  id: variable_qtgui_chooser
  parameters:
    gui_hint: '[2,0,1,1]'
    label: Test Filters
    label0: 'Off'
    label1: Low Pass
    label2: High Pass
    label3: Band Reject
    num_opts: '4'
    option0: '0'
    option1: '1'
    option2: '2'
    option3: '3'
    type: int
    value: '0'
    widget: radio_buttons
  states: {}
- name: freq
  id: variable
  parameters:
    value: freqrange
  states: {}
- name: freqrange
  id: variable_qtgui_range
  parameters:
    gui_hint: '[1,0,1,9]'
    label: Frequency
    start: '10'
    step: '0.01'
    stop: '800'
    value: freqrange_default / 1e6
    widget: slider
  states: {}
- name: freqrange_default
  id: variable
  parameters:
    value: '105500000'
  states: {}
- name: high_cutoff
  id: variable_qtgui_range
  parameters:
    gui_hint: '[7,0,1,9]'
    label: High Cutoff Freq
    start: '.1'
    step: '0.048'
    stop: '1.2'
    value: '.6'
  states: {}
- name: low_cutoff
  id: variable_qtgui_range
  parameters:
    gui_hint: '[6,0,1,9]'
    label: Low Cutoff Freq
    start: '.1'
    step: '0.048'
    stop: '1.2'
    value: '.6'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2.4e6
  states: {}
- name: source_chooser
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 3,0,1,1
    label: Source
    labels: '[''WBFM'', ''NBFM'', ''AM'', ''AM-USB'', ''CW'', ''Test'']'
    num_opts: '0'
    options: '[0, 1, 2, 3, 4, 5]'
    type: int
    value: '0'
  states: {}
- name: squelch
  id: variable
  parameters:
    value: '-20'
  states: {}
- name: testfreq
  id: variable
  parameters:
    value: testfreqrange
  states: {}
- name: testfreqrange
  id: variable_qtgui_range
  parameters:
    gui_hint: '[5,0,1,9]'
    label: Test Frequency
    start: '0'
    step: '0.0001'
    stop: '1.2'
    value: '0.6'
    widget: slider
  states: {}
- name: variable_qtgui_label_0
  id: variable_qtgui_label
  parameters:
    formatter: 'lambda x: f''{x:5f}'''
    gui_hint: '[0,4,1,1]'
    label: 'Freq (MHz): '
    type: real
    value: freqrange
  states: {}
- name: variable_qtgui_range_1
  id: variable_qtgui_range
  parameters:
    gui_hint: '[8,0,1,9]'
    label: Squelch
    rangeType: int
    start: '-100'
    step: '1'
    stop: '0'
    value: squelch
  states: {}
- name: add10
  id: variable_qtgui_msg_push_button
  parameters:
    gui_hint: '[0,5,1,1]'
    label: '+10'
    msgName: pressed
    type: int
    value: '+10'
  states: {}
- name: add1000
  id: variable_qtgui_msg_push_button
  parameters:
    gui_hint: '[0,6,1,1]'
    label: '+1000'
    msgName: pressed
    type: int
    value: '+1000'
  states: {}
- name: add10000
  id: variable_qtgui_msg_push_button
  parameters:
    gui_hint: '[0,7,1,1]'
    label: '+10000'
    msgName: pressed
    type: int
    value: '+10000'
  states: {}
- name: add100000
  id: variable_qtgui_msg_push_button
  parameters:
    gui_hint: '[0,8,1,1]'
    label: '+100000'
    msgName: pressed
    type: int
    value: '+100000'
  states: {}
- name: analog_am_demod_cf_0
  id: analog_am_demod_cf
  parameters:
    audio_decim: '1'
    audio_pass: '10000'
    audio_stop: '11000'
    chan_rate: samp_rate/10
  states: {}
- name: analog_am_demod_cf_0_0
  id: analog_am_demod_cf
  parameters:
    audio_decim: '10'
    audio_pass: '100'
    audio_stop: '6500'
    chan_rate: samp_rate/5
  states: {state: disabled}
- name: analog_nbfm_rx_0
  id: analog_nbfm_rx
  parameters:
    audio_rate: '48000'
    max_dev: 5e3
    quad_rate: '240000'
    tau: '75e-6'
  states: {}
- name: analog_pwr_squelch_xx_0
  id: analog_pwr_squelch_xx
  parameters:
    alpha: '1'
    gate: 'True'
    ramp: '0'
    threshold: variable_qtgui_range_1
    type: complex
  states: {}
- name: analog_pwr_squelch_xx_0_0
  id: analog_pwr_squelch_xx
  parameters:
    alpha: '1'
    gate: 'True'
    ramp: '0'
    threshold: variable_qtgui_range_1
    type: complex
  states: {}
- name: analog_pwr_squelch_xx_0_1
  id: analog_pwr_squelch_xx
  parameters:
    alpha: '1'
    gate: 'True'
    ramp: '0'
    threshold: variable_qtgui_range_1
    type: complex
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: (testfreq * 1e6)
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_1
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: freq * 1e6
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {state: disabled}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '10'
    quad_rate: samp_rate/5
  states: {}
- name: audio_sink_0_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: audio_sink_0_0_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: audio_sink_0_0_1
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: audio_sink_0_0_1_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: audio_sink_0_0_1_0_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {state: disabled}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    decim: '3'
    gain: '1'
    high_cutoff_freq: 6e3
    low_cutoff_freq: 3e3
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: '200'
    win: window.WIN_HAMMING
  states: {}
- name: band_reject_filter_0
  id: band_reject_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: (high_cutoff * 1e6)
    low_cutoff_freq: (low_cutoff * 1e6)
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 1e3
    win: window.WIN_HAMMING
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_msgpair_to_var_0
  id: blocks_msgpair_to_var
  parameters:
    target: freqrange_default
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '1'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '1'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_0_1
  id: blocks_multiply_const_vxx
  parameters:
    const: '5e-1'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_0_1_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '1'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_0_1_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '1'
    type: float
  states: {state: disabled}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_null_sink_0_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_null_sink_1
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_null_sink_2
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_null_source_0
  id: blocks_null_source
  parameters:
    type: complex
  states: {}
- name: blocks_null_source_1
  id: blocks_null_source
  parameters:
    type: complex
  states: {}
- name: blocks_selector_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: '0'
    num_inputs: '1'
    num_outputs: '6'
    output_index: source_chooser
    type: complex
  states: {}
- name: blocks_selector_0_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: source_chooser
    num_inputs: '6'
    num_outputs: '1'
    output_index: '0'
    type: complex
  states: {}
- name: blocks_selector_1
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: '0'
    num_inputs: '1'
    num_outputs: '4'
    output_index: filter_test
    type: complex
  states: {}
- name: blocks_selector_1_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: filter_test
    num_inputs: '4'
    num_outputs: '1'
    output_index: '0'
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_throttle_1
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate /16
    type: complex
  states: {}
- name: blocks_throttle_1_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate / 16
    type: complex
  states: {}
- name: blocks_var_to_msg_0
  id: blocks_var_to_msg
  parameters:
    msgname: freq
    target: freqrange
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      import pmt


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block

          def __init__(self, real_freq=105.4, test_freq=1, source=0):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Source or Test block',   # will show up in GRC
                  in_sig=[np.complex64],
                  out_sig=[np.complex64]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.real_freq = real_freq
              self.test_freq = test_freq
              self.source = source
              self.portName = 'freq'
              self.message_port_register_out(pmt.intern(self.portName))

          def work(self, input_items, output_items):
              if (self.source < 5):
                  #PMT_msg = pmt.to_float(self.real_freq)
                  PMT_msg = pmt.cons(pmt.intern('freq'), pmt.from_float(self.real_freq))
                  output_items[0][:] = self.real_freq
                  self.message_port_pub(pmt.intern(self.portName), PMT_msg)
              else:
                  #PMT_msg = pmt.to_float(self.test_freq)
                  PMT_msg = pmt.cons(pmt.intern('freq'), pmt.from_float(self.test_freq))
                  output_items[0][:] = self.test_freq
                  self.message_port_pub(pmt.intern(self.portName), PMT_msg)
              #PMT_msg = pmt.from_float(self.test_freq)
              #self.message_port_pub(pmt.intern('freq'), pmt.cons(pmt.intern('freq'), pmt.from_double(self.test_freq)))
              #gr.log.error("Unable to print: %s" % repr(e)) 
              output_items[0][:] = input_items[0]
              #self.message_port_pub(pmt.intern(self.portName), PMT_msg)
              return len(output_items[0])
    real_freq: freq * 1e6
    source: source_chooser
    test_freq: '0'
  states: {}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, example_param=1.0):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Embedded Python Block',   # will show up in GRC
                  in_sig=[np.complex64],
                  out_sig=[np.complex64]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.example_param = example_param

          def work(self, input_items, output_items):
              """example: multiply with constant"""
              output_items[0][:] = input_items[0] * self.example_param
              return len(output_items[0])
    example_param: ''
  states: {state: disabled}
- name: epy_block_2
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      import pmt 

      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, real_freq = 1):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Frequency Control',   # will show up in GRC
                  in_sig=[np.complex64],
                  out_sig=[np.complex64]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.inPortName = "in"
              self.freq = real_freq
              self.message_port_register_in(pmt.intern(self.inPortName))
              self.message_port_register_out(pmt.intern("freq"))
              self.set_msg_handler(pmt.intern(self.inPortName), self.handle_msg)
              
          def handle_msg(self, msg):
          	value = pmt.to_python(msg)[1]
          	self.freq += value
          	print (self.freq)
          	freq_msg = pmt.cons(pmt.intern('freq'), pmt.from_double(self.freq))
          	self.message_port_pub(pmt.intern("freq"),freq_msg)

          def work(self, input_items, output_items):
              """example: multiply with constant"""
              output_items[0][:] = input_items[0][:]
              return len(output_items[0])
    real_freq: freq * 1e6
  states: {}
- name: high_pass_filter_0
  id: high_pass_filter
  parameters:
    cutoff_freq: (low_cutoff * 1e6)
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 1e3
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: samp_rate/4
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: samp_rate/8
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: samp_rate/4
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: samp_rate/8
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_1
  id: low_pass_filter
  parameters:
    cutoff_freq: samp_rate/8
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: samp_rate/16
    win: window.WIN_HAMMING
  states: {state: disabled}
- name: low_pass_filter_0_1_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: samp_rate/4
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: samp_rate/8
    win: window.WIN_HAMMING
  states: {state: disabled}
- name: low_pass_filter_0_1_1
  id: low_pass_filter
  parameters:
    cutoff_freq: samp_rate/4
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: samp_rate/8
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_1
  id: low_pass_filter
  parameters:
    cutoff_freq: (high_cutoff * 1e6)
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 1e3
    win: window.WIN_HAMMING
  states: {}
- name: note_0
  id: note
  parameters:
    note: WBFM
  states: {}
- name: note_0_0
  id: note
  parameters:
    note: CW
  states: {}
- name: note_0_1
  id: note
  parameters:
    note: NBFM
  states: {}
- name: note_0_1_0
  id: note
  parameters:
    note: AM
  states: {}
- name: note_0_1_0_0
  id: note
  parameters:
    note: AM-USB
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '512'
    gui_hint: '[2,1,3,8]'
    name: '"Plot"'
    showports: 'True'
    showrf: 'True'
    type: complex
  states: {}
- name: rational_resampler_xxx_1_0
  id: rational_resampler_xxx
  parameters:
    decim: '5'
    interp: '1'
    type: ccf
  states: {}
- name: rational_resampler_xxx_1_0_0
  id: rational_resampler_xxx
  parameters:
    decim: '3'
    interp: '1'
    type: ccf
  states: {state: disabled}
- name: rational_resampler_xxx_1_0_0_0
  id: rational_resampler_xxx
  parameters:
    decim: '10'
    interp: '1'
    type: ccf
  states: {}
- name: rational_resampler_xxx_1_0_0_0_0
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: '1'
    type: ccc
  states: {}
- name: rational_resampler_xxx_1_0_0_0_1
  id: rational_resampler_xxx
  parameters:
    decim: '5'
    interp: '1'
    type: ccf
  states: {state: disabled}
- name: rational_resampler_xxx_1_0_0_0_2
  id: rational_resampler_xxx
  parameters:
    decim: '200'
    interp: '48'
    type: fff
  states: {}
- name: rational_resampler_xxx_1_0_1
  id: rational_resampler_xxx
  parameters:
    decim: '5'
    interp: '1'
    type: ccf
  states: {}
- name: rational_resampler_xxx_1_0_2
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: '1'
    type: ccf
  states: {}
- name: rational_resampler_xxx_1_0_2_0
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: '1'
    type: ccf
  states: {}
- name: rational_resampler_xxx_1_0_2_1
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: '1'
    type: ccf
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    bb_gain0: '20'
    freq0: freq * 1e6
    gain0: '40'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: sub10
  id: variable_qtgui_msg_push_button
  parameters:
    gui_hint: '[0,3,1,1]'
    label: '-10'
    msgName: pressed
    type: int
    value: '-10'
  states: {}
- name: sub1000
  id: variable_qtgui_msg_push_button
  parameters:
    gui_hint: '[0,2,1,1]'
    label: '-1000'
    msgName: pressed
    type: int
    value: '-1000'
  states: {}
- name: sub10000
  id: variable_qtgui_msg_push_button
  parameters:
    gui_hint: '[0,1,1,1]'
    label: '-10000'
    msgName: pressed
    type: int
    value: '-10000'
  states: {}
- name: sub100000
  id: variable_qtgui_msg_push_button
  parameters:
    gui_hint: '[0,0,1,1]'
    label: '-100000'
    msgName: pressed
    type: int
    value: '-100000'
  states: {}

connections:
- [add10, pressed, epy_block_2, in]
- [add1000, pressed, epy_block_2, in]
- [add10000, pressed, epy_block_2, in]
- [add100000, pressed, epy_block_2, in]
- [analog_am_demod_cf_0, '0', rational_resampler_xxx_1_0_0_0_2, '0']
- [analog_am_demod_cf_0_0, '0', blocks_multiply_const_vxx_0_0_1_0_0, '0']
- [analog_nbfm_rx_0, '0', blocks_multiply_const_vxx_0_0_1, '0']
- [analog_pwr_squelch_xx_0, '0', analog_wfm_rcv_0, '0']
- [analog_pwr_squelch_xx_0_0, '0', blocks_complex_to_float_0, '0']
- [analog_pwr_squelch_xx_0_1, '0', analog_nbfm_rx_0, '0']
- [analog_sig_source_x_0, '0', blocks_throttle_0, '0']
- [analog_sig_source_x_1, '0', blocks_selector_0, '0']
- [analog_sig_source_x_1, '0', blocks_selector_0_0, '0']
- [analog_sig_source_x_1, '0', blocks_selector_0_0, '1']
- [analog_sig_source_x_1, '0', blocks_selector_0_0, '2']
- [analog_sig_source_x_1, '0', blocks_selector_0_0, '3']
- [analog_sig_source_x_1, '0', blocks_selector_0_0, '4']
- [analog_wfm_rcv_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [band_pass_filter_0, '0', analog_pwr_squelch_xx_0_1, '0']
- [band_reject_filter_0, '0', blocks_selector_1_0, '3']
- [blocks_complex_to_float_0, '0', blocks_multiply_const_vxx_0_0_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', audio_sink_0_0, '0']
- [blocks_multiply_const_vxx_0_0_0, '0', audio_sink_0_0_0, '0']
- [blocks_multiply_const_vxx_0_0_1, '0', audio_sink_0_0_1, '0']
- [blocks_multiply_const_vxx_0_0_1_0, '0', audio_sink_0_0_1_0, '0']
- [blocks_multiply_const_vxx_0_0_1_0_0, '0', audio_sink_0_0_1_0_0, '0']
- [blocks_null_source_0, '0', blocks_throttle_1_0, '0']
- [blocks_null_source_1, '0', epy_block_2, '0']
- [blocks_selector_0, '0', rational_resampler_xxx_1_0, '0']
- [blocks_selector_0, '1', band_pass_filter_0, '0']
- [blocks_selector_0, '2', rational_resampler_xxx_1_0_0_0, '0']
- [blocks_selector_0, '3', blocks_null_sink_0_0, '0']
- [blocks_selector_0, '3', rational_resampler_xxx_1_0_0_0_1, '0']
- [blocks_selector_0, '4', rational_resampler_xxx_1_0_1, '0']
- [blocks_selector_0, '5', blocks_null_sink_0, '0']
- [blocks_selector_0_0, '0', blocks_selector_1, '0']
- [blocks_selector_1, '0', blocks_selector_1_0, '0']
- [blocks_selector_1, '1', rational_resampler_xxx_1_0_2, '0']
- [blocks_selector_1, '2', rational_resampler_xxx_1_0_2_0, '0']
- [blocks_selector_1, '3', rational_resampler_xxx_1_0_2_1, '0']
- [blocks_selector_1_0, '0', qtgui_sink_x_0, '0']
- [blocks_throttle_0, '0', rational_resampler_xxx_1_0_0_0_0, '0']
- [blocks_throttle_1, '0', blocks_null_sink_1, '0']
- [blocks_throttle_1_0, '0', epy_block_0, '0']
- [blocks_var_to_msg_0, msgout, epy_block_2, in]
- [epy_block_0, '0', blocks_throttle_1, '0']
- [epy_block_0, freq, qtgui_sink_x_0, freq]
- [epy_block_2, '0', blocks_null_sink_2, '0']
- [epy_block_2, freq, blocks_msgpair_to_var_0, inpair]
- [epy_block_2, freq, qtgui_sink_x_0, freq]
- [high_pass_filter_0, '0', blocks_selector_1_0, '2']
- [low_pass_filter_0, '0', analog_pwr_squelch_xx_0, '0']
- [low_pass_filter_0_0, '0', analog_pwr_squelch_xx_0_0, '0']
- [low_pass_filter_0_1_0_0, '0', analog_am_demod_cf_0_0, '0']
- [low_pass_filter_0_1_1, '0', analog_am_demod_cf_0, '0']
- [low_pass_filter_1, '0', blocks_selector_1_0, '1']
- [rational_resampler_xxx_1_0, '0', low_pass_filter_0, '0']
- [rational_resampler_xxx_1_0_0, '0', low_pass_filter_0_1, '0']
- [rational_resampler_xxx_1_0_0_0, '0', low_pass_filter_0_1_1, '0']
- [rational_resampler_xxx_1_0_0_0_0, '0', blocks_selector_0_0, '5']
- [rational_resampler_xxx_1_0_0_0_1, '0', low_pass_filter_0_1_0_0, '0']
- [rational_resampler_xxx_1_0_0_0_2, '0', blocks_multiply_const_vxx_0_0_1_0, '0']
- [rational_resampler_xxx_1_0_1, '0', low_pass_filter_0_0, '0']
- [rational_resampler_xxx_1_0_2, '0', low_pass_filter_1, '0']
- [rational_resampler_xxx_1_0_2_0, '0', high_pass_filter_0, '0']
- [rational_resampler_xxx_1_0_2_1, '0', band_reject_filter_0, '0']
- [rtlsdr_source_0, '0', blocks_selector_0, '0']
- [rtlsdr_source_0, '0', blocks_selector_0_0, '0']
- [rtlsdr_source_0, '0', blocks_selector_0_0, '1']
- [rtlsdr_source_0, '0', blocks_selector_0_0, '2']
- [rtlsdr_source_0, '0', blocks_selector_0_0, '3']
- [rtlsdr_source_0, '0', blocks_selector_0_0, '4']
- [sub10, pressed, epy_block_2, in]
- [sub1000, pressed, epy_block_2, in]
- [sub10000, pressed, epy_block_2, in]
- [sub100000, pressed, epy_block_2, in]

metadata:
  file_format: 1
