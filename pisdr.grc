options:
  parameters:
    generate_options: qt_gui
    id: pisdr
    output_language: python
    title: SDR
  states: {}

blocks:
- name: freq
  id: variable
  parameters:
    value: 105.5e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2048000'
  states: {}
- name: source_chooser
  id: variable_qtgui_chooser
  parameters:
    label: Source
    label0: FM
    label1: Test Signals
    num_opts: '2'
    option0: '0'
    option1: '1'
    type: string
    value: '0'
    widget: radio_buttons
  states: {}
- name: variable_qtgui_range_0
  id: variable_qtgui_range
  parameters:
    start: 86e6
    step: '10000'
    stop: 110e6
    value: freq
  states: {}
- name: analog_fm_demod_cf_0
  id: analog_fm_demod_cf
  parameters:
    audio_decim: '10'
    audio_pass: '15000'
    audio_stop: '20000'
    chan_rate: 250e3
    deviation: '75000'
    gain: '1.0'
    tau: '75e-6'
  states: {state: disabled}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '10'
    quad_rate: 500e3
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {state: disabled}
- name: audio_sink_0_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '1'
    type: float
  states: {state: disabled}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '1'
    type: float
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 100e3
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 1e6
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: 100e6
    fc: variable_qtgui_range_0
    fftsize: '1024'
    plotconst: 'False'
    plottime: 'False'
    showports: 'True'
    showrf: 'True'
    type: complex
  states: {}
- name: rational_resampler_xxx_1
  id: rational_resampler_xxx
  parameters:
    decim: '50'
    interp: '50'
    type: fff
  states: {state: disabled}
- name: rational_resampler_xxx_1_0
  id: rational_resampler_xxx
  parameters:
    decim: '4'
    interp: '1'
    type: ccf
  states: {}
- name: rational_resampler_xxx_1_0_0
  id: rational_resampler_xxx
  parameters:
    decim: '50'
    interp: '50'
    type: fff
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    bb_gain0: '20'
    freq0: variable_qtgui_range_0
    gain0: '40'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: soapy_rtlsdr_source_0
  id: soapy_rtlsdr_source
  parameters:
    center_freq: variable_qtgui_range_0
    gain: '50'
    samp_rate: samp_rate
    type: fc32
  states: {state: disabled}

connections:
- [analog_fm_demod_cf_0, '0', rational_resampler_xxx_1, '0']
- [analog_wfm_rcv_0, '0', rational_resampler_xxx_1_0_0, '0']
- [blocks_multiply_const_vxx_0, '0', audio_sink_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', audio_sink_0_0, '0']
- [low_pass_filter_0, '0', analog_wfm_rcv_0, '0']
- [rational_resampler_xxx_1, '0', blocks_multiply_const_vxx_0, '0']
- [rational_resampler_xxx_1_0, '0', low_pass_filter_0, '0']
- [rational_resampler_xxx_1_0_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [rtlsdr_source_0, '0', qtgui_sink_x_0, '0']
- [rtlsdr_source_0, '0', rational_resampler_xxx_1_0, '0']
- [soapy_rtlsdr_source_0, '0', analog_fm_demod_cf_0, '0']
- [soapy_rtlsdr_source_0, '0', qtgui_sink_x_0, '0']

metadata:
  file_format: 1
