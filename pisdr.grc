options:
  parameters:
    generate_options: qt_gui
    id: pisdr
    output_language: python
    title: SDR
  states: {}

blocks:
- name: bandwidth
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,0,1,1
    label: Bandwidth
    start: '1'
    step: '10'
    stop: 2.5e6
    value: samp_rate
  states: {}
- name: freq
  id: variable
  parameters:
    value: variable_qtgui_range_0
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2.4e6
  states: {}
- name: source_chooser
  id: variable_qtgui_chooser
  parameters:
    label: Source
    labels: '[''WBFM'', ''NBFM'', ''AM'', ''AM-USB'', ''CW'', ''Test'']'
    num_opts: '0'
    options: '[0, 1, 2, 3, 4, 5]'
    type: int
    value: '0'
  states: {}
- name: squelch
  id: variable
  parameters:
    value: '-20'
  states: {}
- name: variable_qtgui_label_0
  id: variable_qtgui_label
  parameters:
    formatter: 'lambda x: f''{x:5f}'''
    gui_hint: 0,1,1,1
    label: 'Frequency (MHz): '
    type: real
    value: variable_qtgui_range_0 / 1e6
  states: {}
- name: variable_qtgui_range_0
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0,1,1
    label: Frequency
    start: '10'
    step: '0.01'
    stop: '800'
    value: '105.5'
  states: {}
- name: variable_qtgui_range_1
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,2,1,1
    label: Squelch
    rangeType: int
    start: '-100'
    step: '1'
    stop: '0'
    value: squelch
  states: {}
- name: analog_am_demod_cf_0
  id: analog_am_demod_cf
  parameters:
    audio_decim: '1'
    audio_pass: '10000'
    audio_stop: '11000'
    chan_rate: samp_rate/10
  states: {}
- name: analog_am_demod_cf_0_0
  id: analog_am_demod_cf
  parameters:
    audio_decim: '10'
    audio_pass: '100'
    audio_stop: '6500'
    chan_rate: samp_rate/5
  states: {state: disabled}
- name: analog_nbfm_rx_0
  id: analog_nbfm_rx
  parameters:
    audio_rate: '48000'
    max_dev: 5e3
    quad_rate: '480000'
    tau: '75e-6'
  states: {}
- name: analog_pwr_squelch_xx_0
  id: analog_pwr_squelch_xx
  parameters:
    alpha: '1'
    gate: 'True'
    ramp: '0'
    threshold: variable_qtgui_range_1
    type: complex
  states: {}
- name: analog_pwr_squelch_xx_0_0
  id: analog_pwr_squelch_xx
  parameters:
    alpha: '1'
    gate: 'True'
    ramp: '0'
    threshold: variable_qtgui_range_1
    type: complex
  states: {}
- name: analog_pwr_squelch_xx_0_1
  id: analog_pwr_squelch_xx
  parameters:
    alpha: '1'
    gate: 'True'
    ramp: '0'
    threshold: variable_qtgui_range_1
    type: complex
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: freq * 1e6
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '10'
    quad_rate: samp_rate/5
  states: {}
- name: audio_sink_0_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: audio_sink_0_0_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: audio_sink_0_0_1
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: audio_sink_0_0_1_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: audio_sink_0_0_1_0_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {state: disabled}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '1'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '1'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_0_1
  id: blocks_multiply_const_vxx
  parameters:
    const: '1'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_0_1_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '1'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_0_1_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '1'
    type: float
  states: {state: disabled}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_null_sink_0_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_selector_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: '0'
    num_inputs: '1'
    num_outputs: '6'
    output_index: source_chooser
    type: complex
  states: {}
- name: blocks_selector_0_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: source_chooser
    num_inputs: '6'
    num_outputs: '1'
    output_index: '0'
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: samp_rate/4
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: samp_rate/8
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: samp_rate/4
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: samp_rate/8
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_1
  id: low_pass_filter
  parameters:
    cutoff_freq: samp_rate/4
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: samp_rate/8
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_1_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: samp_rate/4
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: samp_rate/8
    win: window.WIN_HAMMING
  states: {state: disabled}
- name: low_pass_filter_0_1_1
  id: low_pass_filter
  parameters:
    cutoff_freq: samp_rate/4
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: samp_rate/8
    win: window.WIN_HAMMING
  states: {}
- name: note_0
  id: note
  parameters:
    note: WBFM
  states: {}
- name: note_0_0
  id: note
  parameters:
    note: CW
  states: {}
- name: note_0_1
  id: note
  parameters:
    note: NBFM
  states: {}
- name: note_0_1_0
  id: note
  parameters:
    note: AM
  states: {}
- name: note_0_1_0_0
  id: note
  parameters:
    note: AM-USB
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: bandwidth
    fc: freq * 1e6
    fftsize: '512'
    plotconst: 'False'
    showports: 'True'
    showrf: 'True'
    type: complex
  states: {}
- name: rational_resampler_xxx_1_0
  id: rational_resampler_xxx
  parameters:
    decim: '5'
    interp: '1'
    type: ccf
  states: {}
- name: rational_resampler_xxx_1_0_0
  id: rational_resampler_xxx
  parameters:
    decim: '5'
    interp: '1'
    type: ccf
  states: {}
- name: rational_resampler_xxx_1_0_0_0
  id: rational_resampler_xxx
  parameters:
    decim: '10'
    interp: '1'
    type: ccf
  states: {}
- name: rational_resampler_xxx_1_0_0_0_0
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: '70'
    type: ccc
  states: {}
- name: rational_resampler_xxx_1_0_0_0_1
  id: rational_resampler_xxx
  parameters:
    decim: '5'
    interp: '1'
    type: ccf
  states: {state: disabled}
- name: rational_resampler_xxx_1_0_0_0_2
  id: rational_resampler_xxx
  parameters:
    decim: '200'
    interp: '48'
    type: fff
  states: {}
- name: rational_resampler_xxx_1_0_1
  id: rational_resampler_xxx
  parameters:
    decim: '5'
    interp: '1'
    type: ccf
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    bb_gain0: '20'
    freq0: freq * 1e6
    gain0: '40'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [analog_am_demod_cf_0, '0', rational_resampler_xxx_1_0_0_0_2, '0']
- [analog_am_demod_cf_0_0, '0', blocks_multiply_const_vxx_0_0_1_0_0, '0']
- [analog_nbfm_rx_0, '0', blocks_multiply_const_vxx_0_0_1, '0']
- [analog_pwr_squelch_xx_0, '0', analog_wfm_rcv_0, '0']
- [analog_pwr_squelch_xx_0_0, '0', blocks_complex_to_float_0, '0']
- [analog_pwr_squelch_xx_0_1, '0', analog_nbfm_rx_0, '0']
- [analog_sig_source_x_0, '0', blocks_throttle_0, '0']
- [analog_wfm_rcv_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [blocks_complex_to_float_0, '0', blocks_multiply_const_vxx_0_0_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', audio_sink_0_0, '0']
- [blocks_multiply_const_vxx_0_0_0, '0', audio_sink_0_0_0, '0']
- [blocks_multiply_const_vxx_0_0_1, '0', audio_sink_0_0_1, '0']
- [blocks_multiply_const_vxx_0_0_1_0, '0', audio_sink_0_0_1_0, '0']
- [blocks_multiply_const_vxx_0_0_1_0_0, '0', audio_sink_0_0_1_0_0, '0']
- [blocks_selector_0, '0', rational_resampler_xxx_1_0, '0']
- [blocks_selector_0, '1', rational_resampler_xxx_1_0_0, '0']
- [blocks_selector_0, '2', rational_resampler_xxx_1_0_0_0, '0']
- [blocks_selector_0, '3', blocks_null_sink_0_0, '0']
- [blocks_selector_0, '3', rational_resampler_xxx_1_0_0_0_1, '0']
- [blocks_selector_0, '4', rational_resampler_xxx_1_0_1, '0']
- [blocks_selector_0, '5', blocks_null_sink_0, '0']
- [blocks_selector_0_0, '0', qtgui_sink_x_0, '0']
- [blocks_throttle_0, '0', rational_resampler_xxx_1_0_0_0_0, '0']
- [low_pass_filter_0, '0', analog_pwr_squelch_xx_0, '0']
- [low_pass_filter_0_0, '0', analog_pwr_squelch_xx_0_0, '0']
- [low_pass_filter_0_1, '0', analog_pwr_squelch_xx_0_1, '0']
- [low_pass_filter_0_1_0_0, '0', analog_am_demod_cf_0_0, '0']
- [low_pass_filter_0_1_1, '0', analog_am_demod_cf_0, '0']
- [rational_resampler_xxx_1_0, '0', low_pass_filter_0, '0']
- [rational_resampler_xxx_1_0_0, '0', low_pass_filter_0_1, '0']
- [rational_resampler_xxx_1_0_0_0, '0', low_pass_filter_0_1_1, '0']
- [rational_resampler_xxx_1_0_0_0_0, '0', blocks_selector_0_0, '5']
- [rational_resampler_xxx_1_0_0_0_1, '0', low_pass_filter_0_1_0_0, '0']
- [rational_resampler_xxx_1_0_0_0_2, '0', blocks_multiply_const_vxx_0_0_1_0, '0']
- [rational_resampler_xxx_1_0_1, '0', low_pass_filter_0_0, '0']
- [rtlsdr_source_0, '0', blocks_selector_0, '0']
- [rtlsdr_source_0, '0', blocks_selector_0_0, '0']
- [rtlsdr_source_0, '0', blocks_selector_0_0, '1']
- [rtlsdr_source_0, '0', blocks_selector_0_0, '2']
- [rtlsdr_source_0, '0', blocks_selector_0_0, '3']
- [rtlsdr_source_0, '0', blocks_selector_0_0, '4']

metadata:
  file_format: 1
